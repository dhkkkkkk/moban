# Keil uVision project 工程文件.uvprojx, settings and files
target 工程文件 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 程序下载文件 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\inc;..\USER;..\DS18B20;..\HW
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart2.c can.c led.c key.c timer3.c
  group TASK
    ../DS18B20/: DS18B20.C
  group HW
    ../HW/: GREE.C MIDEA_WATER_HEATER.c TCL.c
